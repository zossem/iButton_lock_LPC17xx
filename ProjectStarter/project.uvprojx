# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c one_wire.c one_wire.h flash_operations.h uart0.h uart0.c flash_operations.c real_time_clock.h real_time_clock.c SysTick_timer.c SysTick_timer.h application_mode.h application_mode.c lock.h lock.c
software components: CMSIS:CORE 6.1.0, Board Support:LED 1.0.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
